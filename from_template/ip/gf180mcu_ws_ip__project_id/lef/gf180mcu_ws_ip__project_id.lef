VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO gf180mcu_ws_ip__project_id
  CLASS BLOCK ;
  FOREIGN gf180mcu_ws_ip__project_id ;
  ORIGIN 0.000 0.000 ;
  SIZE 195.500 BY 59.500 ;
  OBS
      LAYER Metal1 ;
        RECT 0.0 0.0 195.5 59.5 ;
      LAYER Metal2 ;
        RECT 0.0 0.0 195.5 59.5 ;
      LAYER Metal3 ;
        RECT 0.0 0.0 195.5 59.5 ;
      LAYER Metal4 ;
        RECT 0.0 0.0 195.5 59.5 ;
      LAYER Metal5 ;
        RECT 0.0 0.0 195.5 59.5 ;
  END
END gf180mcu_ws_ip__project_id
END LIBRARY

