v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 940 -660 940 -630 {lab=#net1}
N 900 -660 940 -660 {lab=#net1}
N 900 -660 900 -600 {lab=#net1}
C {nmos.sym} 920 -600 0 0 {name=M1 model=M2N7002 device=2N7002 footprint=SOT23 m=1}
